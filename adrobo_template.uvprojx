# Keil uVision project adrobo_template.uvprojx, settings and files
target adrobo_template (6140000::V6.14::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: adrobo_template
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_PORTIN=1 TOOLCHAIN_ARMC6 __ASSERT_MSG DEVICE_ANALOGIN=1 TARGET_CORTEX MBED_BUILD_TIMESTAMP=1594463179.4330058 TRANSACTION_QUEUE_SIZE_SPI=2 TARGET_STM32F303x8 DEVICE_ANALOGOUT=1 __MBED__=1 DEVICE_RTC=1 MULADDC_CANNOT_USE_R7 TARGET_NAME=NUCLEO_F303K8 DEVICE_LPTICKER=1 TARGET_RELEASE DEVICE_PORTINOUT=1 TOOLCHAIN_ARM DEVICE_CRC=1 DEVICE_INTERRUPTIN=1 TARGET_STM32F303K8 DEVICE_SPISLAVE=1 MBED_TRAP_ERRORS_ENABLED=1 TARGET_STM32F3 TARGET_RTOS_M4_M7 __CMSIS_RTOS DEVICE_I2CSLAVE=1 TARGET_STM __FPU_PRESENT=1 DEVICE_I2C=1 DEVICE_USTICKER=1 TARGET_FAMILY_STM32 DEVICE_PORTOUT=1 DEVICE_SLEEP=1 __MBED_CMSIS_RTOS_CM TARGET_NUCLEO_F303K8 DEVICE_SERIAL=1 __CORTEX_M4 TARGET_M4 TARGET_LIKE_CORTEX_M4 TARGET_FF_ARDUINO DEVICE_SPI=1 ARM_MATH_CM4 DEVICE_PWMOUT=1 TARGET_CORTEX_M DEVICE_SERIAL_FC=1 DEVICE_SPI_ASYNCH=1 DEVICE_CAN=1 DEVICE_I2C_ASYNCH=1 TARGET_LIKE_MBED TOOLCHAIN_ARM_STD DEVICE_STDIO_MESSAGES=1
  c misc: -mfloat-abi=hard -c -Wno-reserved-user-defined-literal -fdata-sections -Wno-armcc-pragma-anon-unions -fno-exceptions -mthumb -fshort-enums -fno-c++-static-destructors -Wno-deprecated-register -fshort-wchar -mfpu=fpv4-sp-d16 -Wno-armcc-pragma-push-pop -mcpu=cortex-m4 --target=arm-arm-none-eabi -fno-rtti -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;adrobo;adrobo/QEI;adrobo/SoftwarePWM;mbed-dev;mbed-dev/cmsis;mbed-dev/cmsis/TARGET_CORTEX_M;mbed-dev/drivers;mbed-dev/hal;mbed-dev/hal/storage_abstraction;mbed-dev/platform;mbed-dev/targets/TARGET_STM;mbed-dev/targets/TARGET_STM/TARGET_STM32F3;mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8;mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/TARGET_NUCLEO_F303K8;mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device;mbed-dev/targets/TARGET_STM/TARGET_STM32F3/device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device/TOOLCHAIN_ARM_STD/stm32f303x8.sct
  link misc: --inline --any_contingency --show_full_path --cpu=Cortex-M4 --keep=os_cb_sections --legacyalign
  group adrobo
    adrobo/: adrobo.h Motor.cpp Motor.h Sound.cpp Sound.h
    adrobo/QEI/: QEI.cpp QEI.h
    adrobo/SoftwarePWM/: SoftwarePWM.cpp SoftwarePWM.h
  group adrobo_template
    ./: main.cpp mbed_config.h
  group mbed-dev
    mbed-dev/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-dev/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker.c
    mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/: analogin_device.c analogout_device.c can_device.h common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    mbed-dev/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mbed_tz_context.c mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-dev/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_error_hist.c mbed_error_hist.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device/: cmsis.h cmsis_nvic.h stm32f303x8.h stm32f3xx.h system_stm32f3xx.h us_ticker_data.h
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-dev/: mbed.h
    mbed-dev/cmsis/: mbed_cmsis_conf.h RTE_Components.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/: objects.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/TARGET_NUCLEO_F303K8/: PeripheralNames.h PeripheralPins.c PinNames.h system_clock.c
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/TARGET_STM32F303x8/device/TOOLCHAIN_ARM_STD/: startup_stm32f303x8.S
    mbed-dev/targets/TARGET_STM/TARGET_STM32F3/device/: stm32_hal_legacy.h stm32f3xx_hal.c stm32f3xx_hal.h stm32f3xx_hal_adc.c stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.c stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.c stm32f3xx_hal_can.h stm32f3xx_hal_cec.c stm32f3xx_hal_cec.h stm32f3xx_hal_comp.c stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.c stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.c stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.c stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.c stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.c stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.c stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.c stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.c stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.c stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.c stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.c stm32f3xx_hal_nand.h stm32f3xx_hal_nor.c stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.c stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.c stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.c stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.c stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.c stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.c stm32f3xx_hal_sram.h stm32f3xx_hal_tim.c stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.c stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.c stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.c stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.c stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.c stm32f3xx_hal_wwdg.h stm32f3xx_ll_adc.c stm32f3xx_ll_adc.h stm32f3xx_ll_bus.h stm32f3xx_ll_comp.c stm32f3xx_ll_comp.h stm32f3xx_ll_cortex.h stm32f3xx_ll_crc.c stm32f3xx_ll_crc.h stm32f3xx_ll_dac.c stm32f3xx_ll_dac.h stm32f3xx_ll_dma.c stm32f3xx_ll_dma.h stm32f3xx_ll_exti.c stm32f3xx_ll_exti.h stm32f3xx_ll_fmc.c stm32f3xx_ll_fmc.h stm32f3xx_ll_gpio.c stm32f3xx_ll_gpio.h stm32f3xx_ll_hrtim.c stm32f3xx_ll_hrtim.h stm32f3xx_ll_i2c.c stm32f3xx_ll_i2c.h stm32f3xx_ll_iwdg.h stm32f3xx_ll_opamp.c stm32f3xx_ll_opamp.h stm32f3xx_ll_pwr.c stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.c stm32f3xx_ll_rcc.h stm32f3xx_ll_rtc.c stm32f3xx_ll_rtc.h stm32f3xx_ll_spi.c stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_tim.c stm32f3xx_ll_tim.h stm32f3xx_ll_usart.c stm32f3xx_ll_usart.h stm32f3xx_ll_utils.c stm32f3xx_ll_utils.h stm32f3xx_ll_wwdg.h system_stm32f3xx.c
